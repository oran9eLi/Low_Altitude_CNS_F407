# Keil uVision project low_altitude_cns_f407.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cns_f407
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER
  c include: ..\Core\Inc;..\Debug\Inc;..\App\Inc;..\Bsp\Inc;..\Display\Inc;..\Sensor_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Middlewares\Source\include;..\Middlewares\Source\portable\RVDS\ARM_CM4F;..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core/Src
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_timebase_tim.c
  group Debug
    ../Debug/Src/: debug_console.c debug_cns_demo.c
  group HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_sd.c stm32f4xx_hal_exti.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fsmc.c
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group FreeRTOS
    ../Middlewares/Source/: list.c queue.c tasks.c timers.c
    ../Middlewares/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Source/portable/RVDS/ARM_CM4F/: port.c
  group App
    ../App/Src/: app_tasks.c app_registry.c app_status.c app_alarm.c app_logger.c app_protocol.c app_storage.c
  group Sensor_Driver
    ../Sensor_Driver/Src/: sensor_registry.c mock_sensor.c
  group Display
    ../Display/Src/: display.c
  group Bsp
    ../Bsp/Src/: bsp.c bsp_uart.c bsp_can.c bsp_spi.c bsp_i2c.c bsp_sd.c
